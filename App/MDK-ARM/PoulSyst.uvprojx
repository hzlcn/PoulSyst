# Keil uVision project PoulSyst.uvprojx, settings and files
target PoulSyst (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: PoulSyst +hex
  AfterMake: "D:\Program Files (x86)\Keil_v5\ARM\ARMCC\bin\fromelf.exe" --bin --output ./PoulSyst/PoulSyst.bin ./PoulSyst/PoulSyst.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Drivers/CMSIS/Include;    ..\User;    ..\User\driver;    ..\User\middle;    ..\User\gps;    ..\User\store;    ..\User\qrcode;    ..\User\network;    ..\User\network\w5500;    ..\User\network\sim7600;    ..\User\network\wifi;    ..\User\slave_device;    ..\User\displayer;    ../Middlewares/Third_Party/FreeRTOS/Source/include;    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;    ..\User\app;    ..\User\debug;    ..\User\param;    ..\User\error;    ..\User\middle;    ..\User\upgrade
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User/app
    ../User/app/: apps.c route.c
  group User/middle
    ../User/middle/: usermsg.c poultry.c gps.c store.c debug.c param.c
  group User/network
    ../User/network/: communicate.c network.c sim7600.c w5500_ex.c dhcp.c socket.c w5500.c
  group User/displayer
    ../User/displayer/: display.c lcd.c
  group User/slave_device
    ../User/slave_device/: modbus.c modbus_rtu.c
  group User/*upgrade
    ../User/upgrade/: upgrade.c
  group User/driver
    ../User/driver/: drivers.c crc.c delay.c stmflash.c serial.c rtctime.c w25qxx.c iap.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 4.3.0
